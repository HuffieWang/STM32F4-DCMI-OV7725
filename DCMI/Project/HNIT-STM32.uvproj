# Keil uVision project HNIT-STM32.uvproj, settings and files
target HNIT-STM32 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32-HNIT +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Core;..\FwLib\inc;..\System;..\System\delay;..\System\sys;..\System\usart;..\User;..\Driver\LED;..\Driver\KEY;..\Driver\LCD;..\Driver\SCCB;..\Driver\OV7725;..\Driver\DCMI;..\Driver\SRAM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../CORE/: startup_stm32f40_41xxx.s
  group FwLib
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../System/: stm32f4xx_it.c system_stm32f4xx.c
    ../System/delay/: stm32_delay.c
    ../System/sys/: stm32_sys.c
    ../System/usart/: stm32_usart.c
  group Driver
    ../Driver/LED/: hnit_led.c
    ../Driver/KEY/: hnit_key.c
    ../Driver/LCD/: hnit_lcd.c
    ../Driver/SCCB/: hnit_sccb.c
    ../Driver/OV7725/: hnit_ov7725.c
    ../Driver/DCMI/: hnit_dcmi.c
    ../Driver/SRAM/: hnit_sram.c
  group User
    ../USER/: main.c
